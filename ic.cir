.ic v(                 clk) = +1.0000000000000000000000000
.ic v(                   d) = +0.0000000000000000000000000
.ic v(                  dn) = +0.0000000000000000000000000
.ic v(                  qn) = +0.7105211573870033900000000
.ic v(                   q) = +0.7107004536879331100000000
.ic v(               reset) = +0.0000000000000000000000000
.ic v(                 vdd) = +0.9999999999999998900000000
.ic v(                x1.a) = +0.4445192526332148500000000
.ic v(               x1.an) = +0.4444734543524713200000000
.ic v(               x1.v1) = +0.0000035827414963602687000
.ic v(               x1.v2) = +0.0000032811306089511620000
