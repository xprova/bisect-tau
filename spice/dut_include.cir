.include "/home/Ghaith/example/latch.cir"
