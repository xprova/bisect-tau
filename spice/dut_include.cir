.include "/cygdrive/d/dev/bisect-tau/example/latch.cir"
